# Xenova 로그인 안내문만 공급한다. profile·hostname·인증 설정은 계승한다.
FILESEXTRAPATHS:prepend:xenova := "${THISDIR}/files:"
